# Keil uVision project SubGHz_Phy_PingPong.uvprojx, settings and files
target SubGHz_Phy_PingPong (ARM-ADS)
  device: STM32WLE5JCIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") TZ
  output: SubGHz_Phy_PingPong +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: CORE_CM4,USE_HAL_DRIVER,STM32WLE5xx,__CC_ARM
  c include: ../Core/Inc;../SubGHz_Phy/App;../SubGHz_Phy/Target;../Utilities/trace/adv_trace;../Drivers/STM32WLxx_HAL_Driver/Inc;../Drivers/STM32WLxx_HAL_Driver/Inc/Legacy;../Utilities/misc;../Utilities/sequencer;../Utilities/timer;../Utilities/lpm/tiny_lpm;../Drivers/CMSIS/Device/ST/STM32WLxx/Include;../Middlewares/Third_Party/SubGHz_Phy;../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver;../Drivers/CMSIS/Include;..\SHT\include;..\SHT\libcpu;..\Drivers\BSP\STM32WLxx_LM403;..\Drivers\BSP\DHT11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: stm32wle5xx_flash.sct
  group Application/MDK-ARM
    ./: startup_stm32wle5xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c rtc.c subghz.c stm32_lpm_if.c sys_app.c sys_debug.c timer_if.c usart_if.c usart.c stm32wlxx_it.c stm32wlxx_hal_msp.c user.c
  group Application/User/SubGHz_Phy/App
    ../SubGHz_Phy/App/: app_subghz_phy.c subghz_phy_app.c
  group Application/User/SubGHz_Phy/Target
    ../SubGHz_Phy/Target/: radio_board_if.c
  group SHT/src
    ../SHT/kernel/: comm_thrd.c core.c event.c int.c irq.c mem.c message.c mutex.c period_thrd.c policy.c sched.c sem.c thread.c timer.c
  group SHT/libcpu
    ../SHT/libcpu/: context_rvds.S cpuport.c
  group Drivers/STM32WLxx_HAL_Driver
    ../Drivers/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_rcc.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_flash.c stm32wlxx_hal_flash_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_dma.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cortex.c stm32wlxx_hal.c stm32wlxx_hal_exti.c stm32wlxx_hal_rtc.c stm32wlxx_hal_rtc_ex.c stm32wlxx_hal_subghz.c stm32wlxx_hal_tim.c stm32wlxx_hal_tim_ex.c stm32wlxx_hal_uart.c stm32wlxx_hal_uart_ex.c stm32wlxx_ll_lptim.c stm32wlxx_hal_i2c.c stm32wlxx_hal_i2c_ex.c stm32wlxx_ll_i2c.c stm32wlxx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wlxx.c
  group Middlewares/SubGHz_Phy
    ../Middlewares/Third_Party/SubGHz_Phy/stm32_radio_driver/: lr_fhss_mac.c radio.c radio_driver.c radio_fw.c wl_lr_fhss.c
  group Utilities
    ../Utilities/misc/: stm32_systime.c stm32_mem.c stm32_tiny_sscanf.c stm32_tiny_vsnprintf.c
    ../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../Utilities/sequencer/: stm32_seq.c
    ../Utilities/timer/: stm32_timer.c
    ../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../Utilities/acoral-lib/: bitops.c list.c print.c
  group Drivers/BSP
    ../Drivers/BSP/STM32WLxx_LM403/: stm32wlxx_LM403.c stm32wlxx_LM403_radio.c
    ../Drivers/BSP/DHT11/: dht11.c
  group Readme
    ../Readme/: GPIO引脚使用情况.txt
software components: CMSIS:CORE 4.3.0
